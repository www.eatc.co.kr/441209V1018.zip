# Autodesk Inventor assembly: 441209V1018
## iProperties
Created: 2014-12
Part Number: 441209V1018
Document SubType Name: Assembly
Designer: pc
Author: pc
